# Repository Denhart/uniProject9-10

## KiCad design hw/pcb/antenna_side_new/serial_optical_adaptor.kicad_pcb

Board: 2 copper layers, 40.0 x 58.7 mm, 25 parts (1 on the bottom side), 14 nets.

Parts:
C1, C2, C3, C4, C5, C6, C8, C10, C11: C; C_0805_HandSoldering
C7, C9: 0.1pF; C_0805_HandSoldering
D2: IF-D91
IC1: ATMEGA168PA-A; TQFP-32_7x7mm_Pitch0.8mm
P1: CONN_02X03; CONN_02X03_SMD
P2: Battery; Batt
P3: CONN_01X01; CONN_01X01_SMD
P4: CONN_01X04; CONN_01X04_SMD
R1, R7: 100k; R_0805_HandSoldering
R2: 47k; R_0805_HandSoldering
R3: 1k; R_0805_HandSoldering
R4: R; R_0805_HandSoldering
U1: LM393; SOIC-8-N
U2: LP3984; SOT-23-5
U3: TXB0108; TSSOP-20_4.4x6.5mm_Pitch0.65mm

Connections:
/AVR_RESET: IC1.29, P1.5, R7.2
/AVR_RFFE_SCLK: IC1.8, U3.15
/AVR_RFFE_SDATA: IC1.7, U3.17
/GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, IC1.3, IC1.5, IC1.21, P1.6, P2.2, P4.4, R1.2, R4.2, U1.4, U2.2, U3.11
/ICSP_MISO: IC1.16, P1.1
/ICSP_MOSI: IC1.15, P1.4
/ICSP_SCK: IC1.17, P1.3
/RFFE_SCLK: P4.1, U3.6
/RFFE_SDATA: P4.2, U3.4
/RX: IC1.30, R3.2, U1.1
/VCC: C1.2, C2.2, C3.2, C4.2, C5.2, C7.1, C10.2, D2.2, IC1.4, IC1.6, IC1.18, P1.2, P2.1, P3.1, R2.1, R3.1, R7.1, U1.8, U2.1, U2.3, U3.19
/Vrffe: C6.2, C8.2, C9.2, C11.2, P4.3, U2.5, U3.2, U3.10
unnamed: D2.1, R1.1, U1.3
unnamed: R2.2, R4.1, U1.2

## KiCad design hw/pcb/pc_side/serial_optical_adaptor.kicad_pcb

Parts:
D1: IF-E97
D2: IF-D91
P1: USB_B
P3: CONN_01X04; Pin_Header_Straight_1x04
R1: 100k; R_0603_HandSoldering
R2: 47k; R_0603_HandSoldering
R3: 1k; R_0603_HandSoldering
R4, R5: 4k7; R_0603_HandSoldering
R6: 100; R_0603_HandSoldering
RV1: 10k; smd_murrata_trimmer_pvz3a
U1: LM393; SOIC-8-N
U2: CP2102; QFN-28-1EP_5x6mm_Pitch0.5mm

Connections:
/CTS: U2.23 (CTS)
/D+: P1.3 (D+), U2.4 (D+)
/D-: P1.2 (D-), U2.5 (D-)
/DCD: U2.1 (DCD)
/DSR: U2.27 (DSR)
/DTR: U2.28 (DTR)
/GND: P1.4 (GND), P1.5 (shield), R1.2, R5.2, RV1.3, U1.4 (V-), U2.3 (GND), U2.29 (PAD); also elsewhere on the board
/RI: U2.2 (RI)
/RST: U2.9 (/RST)
/RTS: U2.24 (RTS)
/RX: R3.2, U1.1, U2.25 (RXD); also elsewhere on the board
/SUSP1: U2.12 (SUSPEND)
/SUSP2: U2.11 (/SUSPEND)
/TX: U1.6 (_), U2.26 (TXD); also elsewhere on the board
unnamed: D1.1 (A), R6.2
unnamed: D1.2 (K), U1.7
unnamed: D2.1 (A), R1.1, U1.3 (+)
unnamed: R2.2, RV1.1
unnamed: R4.2, R5.1, U1.5 (+)
unnamed: RV1.2, U1.2 (_)

Notes on the sheet:
RECEIVER
TRANSMITTER
FIBER OPTIC CABLE

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
Board: 2 copper layers, 23.2 x 58.8 mm, 14 parts (0 on the bottom side), 13 nets.

Other parts of the board:
C4: C; C_0603_HandSoldering
P2: CONN_01X06; Pin_Header_Straight_1x06

Their connections:
/GND: C4.1, P2.1; also elsewhere on the board
/RX: P2.5; also elsewhere on the board
/TX: P2.4; also elsewhere on the board

## KiCad design mockups/001-trianglefeed/pcb/001-trianglefeed.kicad_pcb

Board: 2 copper layers, 62.0 x 130.0 mm, 10 parts (0 on the bottom side), 5 nets.

Parts:
A1, A2: ANTENNA; Measurement_Point_Square-SMD-Pad_Small
C1, C2, C3, C4: C; C_0603_HandSoldering
L1, L2: L; C_0603_HandSoldering
P1, P2: SMA; Measurement_Point_Square-SMD-Pad_Small

Connections:
/Ant1: A1.1, C1.1, C3.1, L1.1
/Ant2: A2.1, C2.1, C4.1, L2.1
/GND: C3.2, C4.2, L1.2, L2.2
unnamed: C1.2, P1.1
unnamed: C2.2, P2.1

## Commit log (part)

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2016-05-24 LTE history done
2016-05-24 Satimo
2016-05-24 Satimo chamber
2016-05-25 AM analysis/fdtd_mesh.pdf AM analysis/leap_frog.pdf AM analysis/yee_3d.pdf
2016-05-25 M analysis/fdtd.tex
2016-05-25 M bib/sources.bib
2016-05-25 M sec/analysis/fdtd.tex
2016-05-26 M rep/sec/analysis/mimo.tex
2016-05-27 Init prob
2016-05-27 removed init prob
2016-05-27 M rep/bib/sources.bib M rep/img/analysis/satimo.pdf M rep/img/analysis/satimo.svg M rep/master.tex
2016-05-27 M analysis/mimo.tex A analysis/vna.tex
2016-05-27 AM analysis/vnaWaves.pdf
2016-05-27 ballade
2016-05-28 Således
2016-05-29 M analysis/mimo.tex
2016-05-29 Most of the conclusion done
2016-05-30 M rep/bib/sources.bib M rep/sec/analysis/tuners.tex
2016-05-30 AM analysis/ideal_reflecResponse.pdf
2016-05-30 spasser
2016-05-30 AM analysis/antenna_limitations.pdf D analysis/antenna_limitations.png
2016-05-30 intro
2016-05-30 M rep/sec/analysis/satimo.tex
2016-05-30 Corrections
2016-05-30 Hald bald
2016-05-31 Mule
2016-05-31 ballerider
2016-05-31 Corrections main report done
2016-05-31 danbedearm
2016-06-01 Corrections before search-and-replace
2016-06-01 Non-resonant -> Dual-feed
2016-06-01 Abstract done
2016-06-08 Blah
2016-06-12 Hallo
2016-06-13 Intro for paper
2016-06-13 Making plots
2016-06-13 Measurements
2016-06-13 Checking eff plot
2016-06-13 Isolation loss
2016-06-13 komma
2016-06-14 AM article/img/3d_drawing.pdf A article/img/sim A article/img/sim/corr AM article/img/sim/corr/correlation.pdf A article/img/sim/corr/paperplot.py A article/img/sim/corr/plot_correlation.py A article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
2016-06-14 M img/sim/corr/correlation.pdf M img/sim/corr/plot_correlation.py M img/sim/eff/eff_ac1/0.6.txt M img/sim/eff/eff_ac1/0.9.txt M img/sim/eff/eff_ac1/1.2.txt M img/sim/eff/eff_ac1/1.5.txt M img/sim/eff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
2016-06-14 A img/sim A img/sim/corr AM img/sim/corr/correlation.pdf A img/sim/corr/paperplot.py A img/sim/corr/plot_correlation.py A img/sim/corr/side A img/sim/corr/side/corr_side.txt A img/sim/corr/side/plotc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
2016-06-14 M sim/corr/correlation.pdf M sim/corr/plot_correlation.py
2016-06-14 Haha
2016-06-16 M img/3d_drawing.pdf
2016-06-16 M article/img/3d_drawing.pdf
2016-06-16 Pres
2016-06-16 M sec/simulations.tex
2016-06-16 Data
2016-06-16 splitsweep
2016-06-17 mapper
2016-06-20 M pres/pres.tex M pres/sec/henrik.tex
2016-06-20 A img/henrik AM img/henrik/all_td.pdf A img/henrik/dp AM img/henrik/dp/efficiency-ac2-top.pdf AM img/henrik/dp/efficiency-ac3-side.pdf AM img/henrik/dp/s11_top_sweep.pdf AM img/henrik/dp/s12_top_swee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
2016-06-20 i123
2016-06-21 M pres/sec/henrik.tex
2016-06-21 AM henrik/schematic_tuning.pdf
2016-06-22 M henrik/schematic_tuning.pdf
2016-06-22 M pres/img/henrik/all_td.pdf M pres/sec/henrik.tex
2016-06-23 M sec/henrik.tex
2016-06-23 Spelling mistake
